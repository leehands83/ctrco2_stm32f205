# IAR project 190208_CTRco2.ewp, settings and files
configuration 190208_CTRco2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205RB ST STM32F205RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F205xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F2xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 190208_CTRco2.hex
  ILINK.IlinkOutputFile: 190208_CTRco2.out
  ILINK.IlinkIcfFile: stm32f205xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f205xx.s
  group Application/Option
    ../Inc/: Option.h
  group Application/User
    ../Src/: main.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f2xx_it.c stm32f2xx_hal_msp.c
  group Application/User/Inc
    ../Inc/: Ascii.h DataTypes.h Errors.h hdc1080.h hw_config.h includes.h
  group Application/User/Src
    ../Src/: hw_config.c main.c
  group Application/User/Src/Handle
    ../Src/Handle/: Hdl_As1115.c Hdl_Hdc1080.c Hdl_Led.c Hdl_Scd30.c Hdl_Shell.c Hdl_Sys.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_pcd.c stm32f2xx_ll_usb.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_i2c.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
